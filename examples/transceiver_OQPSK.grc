<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_OQPSK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using OQPSK PHY</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2480000000</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>labels</key><value>[str(i) for i in range(11, 27)]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_char</key>
<param><key>id</key><value>blocks_complex_to_interleaved_char_0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_char</key>
<param><key>id</key><value>blocks_complex_to_interleaved_char_0_0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/tmp/sensor.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>file</key><value>/tmp/sensorAPPRec.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0_0</value></param>
<param><key>file</key><value>/tmp/sensorPDURec.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("Hello World!\n")</value></param>
<param><key>period</key><value>1500</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>error_rate</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>fec_ber_bf</key>
<param><key>id</key><value>fec_ber_bf_0</value></param>
<param><key>test_mode</key><value>False</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_1_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_1_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>ieee802_15_4_rime_stack</key>
<param><key>id</key><value>ieee802_15_4_rime_stack_0</value></param>
<param><key>bc_channels</key><value>[129]</value></param>
<param><key>rime_add</key><value>[23,42]</value></param>
<param><key>ruc_channels</key><value>[132]</value></param>
<param><key>uc_channels</key><value>[131]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>4e6</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>4000000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>400000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>400000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_interleaved_char_0</source_block_id><sink_block_id>fec_ber_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_interleaved_char_0_0</source_block_id><sink_block_id>fec_ber_bf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>strobe</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdus</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>fec_ber_bf_0</source_block_id><sink_block_id>error_rate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_ber_bf_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_1</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_1_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_1_0_0</source_block_id><sink_block_id>blocks_file_sink_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_1_0</sink_block_id><source_key>app out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>app out</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_1</sink_block_id><source_key>pdu out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_1_0_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>blocks_complex_to_interleaved_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>bcout</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>toMAC</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>blocks_complex_to_interleaved_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
